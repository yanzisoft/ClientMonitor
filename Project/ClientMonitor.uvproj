# Keil uVision project ClientMonitor.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UartIT
  c flags: Optim=1
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\Libraries\startup;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_tim.c
  group USER
    ../USER/: main.cpp packethelper.cpp TestPacketHelper.cpp redirect.c usart.c stm32f10x_it.cpp DisassembleBuffer.cpp UsartSendData.cpp delay.c
  group startup
    ../Libraries/startup/: startup_stm32f10x_md.s
